# Autodesk Inventor assembly: A17-13
## iProperties
Created: 2008-07
Part Number: A17-13
Document SubType Name: Assembly
Designer: y-shimohigashi
Stock Number: A17-13
Author: y-shimohigashi
