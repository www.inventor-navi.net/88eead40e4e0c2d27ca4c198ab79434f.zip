# Autodesk Inventor assembly: A17-14
## iProperties
Created: 2008-07
Part Number: A17-14
Document SubType Name: Assembly
Designer: y-shimohigashi
Author: y-shimohigashi
