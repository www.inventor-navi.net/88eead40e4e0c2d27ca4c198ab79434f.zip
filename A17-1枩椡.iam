# Autodesk Inventor assembly: A17-1万力
## iProperties
Created: 2008-07
Part Number: A17-1万力
Document SubType Name: Assembly
Designer: y-shimohigashi
Author: y-shimohigashi
