# Autodesk Inventor assembly: A17-12
## iProperties
Created: 2008-07
Part Number: A17-12
Document SubType Name: Assembly
Designer: y-shimohigashi
Stock Number: A17-12
Author: y-shimohigashi
